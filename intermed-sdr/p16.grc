<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_filts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(n_filts, n_filts, 1/float(sps), 0.35, 11*sps*n_filts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>int (samp_rate * symbol_time)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>1/symbol_time</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_time</value></param>
<param><key>value</key><value>100e-6</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-0.5</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/sdr/class/class_2_projects/11_extracting_bits/input_waveform.bb</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_1</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_1_0</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_correlate_access_code_bb</key>
<param><key>id</key><value>digital_correlate_access_code_bb_0</value></param>
<param><key>access_code</key><value>0101010101010101</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>threshold</key><value>0</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_xx_0</value></param>
<param><key>access_code</key><value>0101010101010101</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>preamble</value></param>
<param><key>threshold</key><value>0</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>n_filts</value></param>
<param><key>init_phase</key><value>16</value></param>
<param><key>loop_bw</key><value>6.28/100</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Draw input BB"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.2</value></param>
<param><key>ymin</key><value>-0.2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Final"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>symbol_rate</value></param>
<param><key>tr_delay</key><value>5e-3</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.2</value></param>
<param><key>ymin</key><value>-0.2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Simple Tag"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>symbol_rate</value></param>
<param><key>tr_delay</key><value>5e-3</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.2</value></param>
<param><key>ymin</key><value>-0.2</value></param>
</block>
<block>
<key>reveng_correlate_access_code_xx_ts_fl</key>
<param><key>id</key><value>reveng_correlate_access_code_xx_ts_fl_0</value></param>
<param><key>access_code</key><value>0101010101010101</value></param>
<param><key>len</key><value>2</value></param>
<param><key>tagname</key><value>packet_len</value></param>
<param><key>threshold</key><value>0</value></param>
</block>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_uchar_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_1</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>digital_correlate_access_code_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_bb_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_bb_0</source_block_id><sink_block_id>reveng_correlate_access_code_xx_ts_fl_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0</source_block_id><sink_block_id>blocks_uchar_to_float_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>reveng_correlate_access_code_xx_ts_fl_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>reveng_correlate_access_code_xx_ts_fl_0</source_block_id><sink_block_id>blocks_uchar_to_float_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
